#Add feautures

PACKAGECONFIG_append = " gstreamer"
