#Add feautures

PACKAGECONFIG_append = " sql-sqlite accessibility examples tslib icu udev openssl alsa pulseaudio nis widgets libproxy libinput"
