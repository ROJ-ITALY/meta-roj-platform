# Remove gst-examples (gtk-play and gst-play) from RDEPENDS_${PN}-apps

RDEPENDS_${PN}-apps_remove = "gst-examples"
